# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IO-LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\stc15w4-car
  group Source Group 1
    ./: main.c uart.c
